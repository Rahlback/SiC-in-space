# IAR project SiCMiC.ewp, settings and files
configuration SiCMiC (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053C6 ST STM32L053C6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Lib\msp\inc; ..\Lib\msp\inc; ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SiCMiC.hex
  ILINK.IlinkOutputFile: SiCMiC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: eeprom_circular.c interface_flags.c Piezo.c power_management.c start_test.c tools.c main.c gpio.c adc.c dac.c i2c.c iwdg.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Lib/Inc
    ../Lib/msp/inc/: msp_configuration.h msp_constants.h msp_crc.h msp_debug.h msp_endian.h msp_exp.h msp_exp_callback.h msp_exp_definitions.h msp_exp_error.h msp_exp_frame.h msp_exp_handler.h msp_exp_state.h msp_opcodes.h msp_seqflags.h
  group Lib/Src
    ../Lib/msp/src/: msp_crc.c msp_endian.c msp_exp_callback.c msp_exp_frame.c msp_exp_state.c msp_handlers.c msp_seqflags.c
